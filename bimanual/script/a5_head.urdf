Commit message: for 20.04+

File: bimanual/script/a5_head.urdf (robot description, URDF)
Before this commit: robot A5S, 7 links, 6 joints
Links:
- link link6: mass 0.58 -> 0.101
